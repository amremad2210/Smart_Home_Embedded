# IAR project HIMI_WS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PART_TM4C123GH6PM
  ICCARM.CCIncludePath2: inc; ..\..\Common\inc; C:\ti\TivaWare_C_Series-2.2.0.295\inc; C:\ti\TivaWare_C_Series-2.2.0.295\driverlib; C:\ti\TivaWare_C_Series-2.2.0.295
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: C:\ti\TivaWare_C_Series-2.2.0.295\driverlib\ewarm\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c startup_ewarm.c
  group Common/inc
    ../Common/inc/: common_macros.h Types.h
  group Common/inc/mcal
    ../Common/inc/mcal/: mcal_adc.h mcal_eeprom.h mcal_gpio.h mcal_gpt.h mcal_systick.h mcal_uart.h
  group Common/src/mcal
    ../Common/src/mcal/: mcal_adc.c mcal_eeprom.c mcal_gpio.c mcal_gpt.c mcal_systick.c mcal_uart.c
  group inc/hal
    inc/hal/: hal_comm.h hal_keypad.h hal_lcd.h hal_potentiometer.h hal_rgb_led.h
  group src/hal
    src/: hal_comm.c hal_keypad.c hal_lcd.c hal_potentiometer.c hal_rgb_led.c
