# IAR project IntegrationTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: PART_TM4C123GH6PM
  ICCARM.CCIncludePath2: inc; ..\..\Common\inc; C:\ti\TivaWare_C_Series-2.2.0.295\inc; C:\ti\TivaWare_C_Series-2.2.0.295\driverlib; C:\ti\TivaWare_C_Series-2.2.0.295
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: C:\ti\TivaWare_C_Series-2.2.0.295\driverlib\ewarm\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: test_main.c control_main.c hmi_main.c startup_ewarm.c
  group Common/inc
    ../Common/inc/: common_macros.h Types.h
  group Common/inc/mcal
    ../Common/inc/mcal/: mcal_adc.h mcal_eeprom.h mcal_gpio.h mcal_gpt.h mcal_i2c.h mcal_pwm.h mcal_systick.h mcal_uart.h
  group Common/src/mcal
    mocks/: mock_mcal_adc.c mock_mcal_eeprom.c mock_mcal_gpio.c mock_mcal_gpt.c mock_mcal_i2c.c mock_mcal_pwm.c mock_mcal_systick.c mock_mcal_uart.c
  group inc/hal
    inc/hal/: hal_buzzer.h hal_comm.h hal_eeprom.h hal_motor.h
  group src/hal
    src/hal/: hal_buzzer.c hal_comm.c hal_eeprom.c hal_motor.c
    src/: hal_lcd.c hal_keypad.c hal_rgb_led.c hal_potentiometer.c
